<?xml version="1.0" encoding="utf-8"?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">
	<SchemaVersion>1.0</SchemaVersion>
	<Target>
		<TargetName>ArTeller_firmware</TargetName>
		<ToolsetNumber>0x4</ToolsetNumber>
		<ToolsetName>ARM-ADS</ToolsetName>
		<TargetOption>
			
			<DebugOpt>
				<uSim>0</uSim>
				<uTrg>1</uTrg>
				<nTsel>11</nTsel>
				<pMon>STLink\ST-LINKIII-KEIL_SWO.dll</pMon>
				
			</DebugOpt>
			<TargetDriverDllRegistry>
				<SetRegEntry>
					<Number>0</Number>
					<Key>ST-LINKIII-KEIL_SWO</Key>
					<Name>UL2CM3(-S0 -C0 -P0 -FD20020000 -FC1000 -FN2 -FF0stm32f7x_2048 -FS08000000 -FL0200000 -FP0($$Device:STM32F769NIHx$CMSIS/Flash/STM32F7x_2048.FLM) -FF1stm32f7xtcm_2048 -FS1200000 -FL1200000 -FP1($$Device:STM32F769NIHx$CMSIS/Flash/STM32F7xTCM_2048.FLM))</Name>
				</SetRegEntry>
			</TargetDriverDllRegistry>
		</TargetOption>
	</Target>
</ProjectOpt>